options:
  parameters:
    author: OpenAI Codex
    category: '[LoRa Experiments]'
    comment: B210 现场 IQ 采集：实时频谱、LoRa CRC 统计和可控 complex64 写盘。
    description: 采集前先实时解调并检查 CRC，确认位置可用后再打开正式录制开关。
    generate_options: qt_gui
    id: usrp_iq_collector
    output_language: python
    title: USRP LoRa 实时 CRC 可视化采集器
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    comment: LoRa 信号带宽
    value: 125e3
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: STM32 当前固定使用 487.7 MHz
    value: 487.7e6
  states: {}
- name: cr
  id: variable
  parameters:
    comment: 编码率索引 4 = CR 4/8；显式包头会覆盖该预设
    value: '4'
  states: {}
- name: device_args
  id: variable
  parameters:
    comment: 默认留空，让 UHD 自动选择当前唯一的 USRP；多设备时再填 serial=XXXXXXXX
    value: ''''''
  states: {}
- name: duration
  id: variable
  parameters:
    comment: 覆盖 120 包 x 6 s 并留启动/尾部余量，单位秒
    value: '780'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: 手动固定增益；正式实验中不要启用 AGC
    value: '20'
  states: {}
- name: capture_experiment
  id: variable
  parameters:
    comment: 连续采集实验编号；每个新 cfile 递增，用于保证逐包输出不重名
    value: '0'
  states: {}
- name: capture_session
  id: variable
  parameters:
    comment: 同一实验计划中的 session 编号
    value: '0'
  states: {}
- name: capture_location
  id: variable
  parameters:
    comment: 位置短标签，只允许小写字母、数字和连字符
    value: '"lab1"'
  states: {}
- name: capture_condition
  id: variable
  parameters:
    comment: 采集条件：highsnr/lowsnr/noiseonly/interference 等
    value: '"highsnr"'
  states: {}
- name: capture_run
  id: variable
  parameters:
    comment: 相同 experiment/session/location/condition 下的重复轮次
    value: '0'
  states: {}
- name: capture_root
  id: variable
  parameters:
    comment: 正式原始 IQ 统一保存在 lora-rfsr-savaux/data/raw/ota
    value: '"../../../lora-rfsr-savaux/data/raw/ota"'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: 可被 trim 脚本直接解析的原始 complex64 文件名；每次采集前递增 capture_experiment 或 capture_run
    value: capture_root + ('/rxcap_exp%03d_sess%03d_loc%s_cond%s_run%03d_sf%d_bw%d_fs%d_pre%d_sw%02X_cr4%d_crc1_fc%d_rxg%s.cfile' % (capture_experiment, capture_session, capture_location, capture_condition, capture_run, sf, int(bw), int(samp_rate), preamble_len, sync_word, cr + 4, int(center_freq), ('%g' % gain).replace('.', 'p')))
  states: {}
- name: pay_len
  id: variable
  parameters:
    comment: 当前空口 PHY payload 长度；显式包头会自动解析
    value: '33'
  states: {}
- name: preamble_len
  id: variable
  parameters:
    comment: 当前 Branch4 前导码长度
    value: '16'
  states: {}
- name: record_enabled
  id: variable_qtgui_toggle_switch
  parameters:
    comment: 默认关闭；预检 CRC 合格后再打开，打开后请复位 STM32
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: 正式录制（绿色=正在写盘）
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: USRP 模拟前端带宽
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: native 2 MS/s 采集；trim 后拆成两个 1 MS/s phase，每个再提供四个 250 kS/s 训练视图
    value: 2e6
  states: {}
- name: settle_time
  id: variable
  parameters:
    comment: 启动后丢弃的调谐暂态，单位秒
    value: '1'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: 当前 Branch4 发射端使用 SF12
    value: '12'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: LoRa private sync word
    value: '0x12'
  states: {}
- name: blocks_copy_record
  id: blocks_copy
  parameters:
    comment: 录制阀门：关闭时仍可看频谱和 CRC，但不向正式 IQ 文件写入样点
    enabled: record_enabled
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: 无文件头的 numpy.complex64 IQ
    file: str(output_file)
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: 仅统计录制开关打开后的样点；写满 duration 后停止文件支路，监视界面仍可继续运行
    num_items: int(duration * samp_rate)
    type: complex
  states: {}
- name: blocks_null_sink_payload
  id: blocks_null_sink
  parameters:
    comment: CRC 块在启用 crc_check 时要求 payload 和 crc_check 两个流输出都有连接
    type: byte
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: 丢弃 USRP 启动和调谐暂态
    minoutbuf: int(samp_rate / bw * (2**sf + 2))
    num_items: int(settle_time * samp_rate)
    type: complex
  states: {}
- name: crc_packet_statistics
  id: epy_block
  parameters:
    _source_code: |-
      import collections
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Convert one CRC byte per decoded packet into live packet statistics."""

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="CRC Packet Statistics",
                  in_sig=[np.uint8],
                  out_sig=[
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                      np.float32,
                  ],
              )
              self.total = 0
              self.valid = 0
              self.recent = collections.deque(maxlen=10)

          def work(self, input_items, output_items):
              source = input_items[0]
              count = min(
                  len(source),
                  *(len(output) for output in output_items),
              )
              for index in range(count):
                  current = 1.0 if int(source[index]) != 0 else 0.0
                  self.total += 1
                  self.valid += int(current)
                  self.recent.append(current)

                  output_items[0][index] = current
                  output_items[1][index] = float(self.total)
                  output_items[2][index] = float(self.valid)
                  output_items[3][index] = 100.0 * self.valid / self.total
                  output_items[4][index] = (
                      100.0 * sum(self.recent) / len(self.recent)
                  )
              return count
    comment: 每个完整解码包输入一个 CRC 0/1，统计累计成功率和最近 10 包成功率
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    comment: 兼容当前 RadioConda 旧版 gr-lora_sdr：打开 crc_check 字节流，终端同时打印解码 payload 和 CRC 结果
    output_crc_check: 'True'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: int(bw)
    center_freq: int(center_freq)
    comment: 实时检测前导码，并估计/补偿 CFO、STO 和 SFO
    impl_head: 'False'
    os_factor: int(samp_rate / bw)
    preamb_len: int(preamble_len)
    sf: int(sf)
    show_log_port: 'False'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    comment: 显式包头模式；CR、payload 长度和 CRC 标志从空口包头解析
    cr: int(cr)
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: int(pay_len)
    print_header: 'False'
  states: {}
- name: qtgui_number_sink_crc
  id: qtgui_number_sink
  parameters:
    color1: ("white", "black")
    color2: ("white", "black")
    color3: ("white", "black")
    color4: ("blue", "red")
    color5: ("blue", "red")
    comment: 本包 CRC：1=PASS、0=FAIL；位置预检至少观察 5–10 包
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,1,1,3
    label1: '"\u672C\u5305 CRC"'
    label2: '"\u5DF2\u89E3\u7801\u5305\u6570"'
    label3: '"CRC \u6210\u529F\u6570"'
    label4: '"\u7D2F\u8BA1 CRC \u6210\u529F\u7387"'
    label5: '"\u6700\u8FD1 10 \u5305\u6210\u529F\u7387"'
    max: '120'
    min: '0'
    name: '"LoRa \u5B9E\u65F6 CRC \u8D28\u91CF"'
    nconnections: '5'
    type: float
    unit1: '" (1=PASS)"'
    unit2: '" packets"'
    unit3: '" packets"'
    unit4: '" %"'
    unit5: '" %"'
    update_time: '0.2'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: RX2 实时监视：频谱、瀑布图和时域 IQ；不改变保存到文件的样点
    fc: center_freq
    fftsize: '4096'
    gui_hint: 1,0,1,4
    name: '"USRP RX2 LoRa IQ"'
    plotconst: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: rf_bandwidth
    center_freq0: center_freq
    comment: B210 通道 0；手动固定增益。
    dev_addr: device_args
    gain0: gain
    minoutbuf: int(samp_rate / bw * (2**sf + 2))
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_copy_record, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_copy_record, '0']
- [blocks_skiphead_0, '0', lora_sdr_frame_sync_0, '0']
- [blocks_skiphead_0, '0', qtgui_sink_x_0, '0']
- [crc_packet_statistics, '0', qtgui_number_sink_crc, '0']
- [crc_packet_statistics, '1', qtgui_number_sink_crc, '1']
- [crc_packet_statistics, '2', qtgui_number_sink_crc, '2']
- [crc_packet_statistics, '3', qtgui_number_sink_crc, '3']
- [crc_packet_statistics, '4', qtgui_number_sink_crc, '4']
- [lora_sdr_crc_verif_0, '0', blocks_null_sink_payload, '0']
- [lora_sdr_crc_verif_0, '1', crc_packet_statistics, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
