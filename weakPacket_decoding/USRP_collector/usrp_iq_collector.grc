options:
  parameters:
    author: OpenAI Codex
    category: '[LoRa Experiments]'
    comment: B210 离线 IQ 采集：487.7 MHz、500 kS/s、complex64 文件。
    description: 采集固定帧 SX1276 信号，供弱包解调和 GLS 离线实验使用。
    generate_options: qt_gui
    id: usrp_iq_collector
    output_language: python
    title: USRP 离线 IQ 采集器
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    comment: STM32 当前固定使用 487.7 MHz
    value: 487.7e6
  states: {}
- name: device_args
  id: variable
  parameters:
    comment: 当前 B210 序列号
    value: '''serial=2603160'''
  states: {}
- name: duration
  id: variable
  parameters:
    comment: 实际保存时长，单位秒
    value: '120'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: 手动固定增益；正式实验中不要启用 AGC
    value: '20'
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: 原始 complex64 输出文件；已有文件会被覆盖
    value: '"data/branch4_fixed/high_snr/sf10_bw125_fs500_pre32_sw34_r001.bin"'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: USRP 模拟前端带宽
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 125 kHz LoRa 带宽的 4 倍过采样
    value: 500e3
  states: {}
- name: settle_time
  id: variable
  parameters:
    comment: 启动后丢弃的调谐暂态，单位秒
    value: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: 无文件头的 numpy.complex64 IQ
    file: output_file
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: 达到指定采样点数后自动结束流图
    num_items: int(duration * samp_rate)
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: 丢弃 USRP 启动和调谐暂态
    num_items: int(settle_time * samp_rate)
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: RX2 实时监视：频谱、瀑布图和时域 IQ；不改变保存到文件的样点
    fc: center_freq
    fftsize: '4096'
    name: '"USRP RX2 LoRa IQ"'
    plotconst: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: rf_bandwidth
    center_freq0: center_freq
    comment: B210 通道 0；手动固定增益。
    dev_addr: device_args
    gain0: gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_sink_x_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
